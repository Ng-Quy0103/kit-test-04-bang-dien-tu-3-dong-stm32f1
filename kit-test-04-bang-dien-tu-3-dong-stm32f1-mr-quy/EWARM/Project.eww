<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\kit-test-04-bang-dien-tu-3-dong-stm32f1-mr-quy.ewp</path>
  </project>
  <batchBuild />
</workspace>
